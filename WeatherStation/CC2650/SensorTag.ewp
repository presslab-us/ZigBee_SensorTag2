# IAR project SensorTag.ewp, settings and files
configuration SensorTag (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2650_SENSORTAG=0060; LIGHTSENSOR_ENABLED; DUSTSENSOR_ENABLED; GASSENSOR_ENABLED; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_REPORT; xZCL_EZMODE; xZCL_GROUPS; ZCL_STANDALONE; ZCL_PORT_MAX_ENDPOINTS=6; ZG_SECURE_ENABLED; TI_DRIVERS_I2C_INCLUDED; TI_DRIVERS_SPI_INCLUDED; ewarm; USE_ICALL; HEAPMGR_SIZE=5000; ICALL_HOOK_ABORT_FUNC=halAssertHandler; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_7X7; xFORCE_REPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg\compiler.opt.defs; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.cfg
  ICCARM.CCIncludePath2: $PROJ_DIR$; scif; ..\..\Source; ..\..\..\common\CC26xx; ..\..\..\common\CC26xx\appport; ..\..\..\common\CC26xx\SensorTag; ..\..\..\..\..\Components\applib\heap; ..\..\..\..\..\Components\mac\include\cc26xx; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_common\cc26xx; ..\..\..\..\..\Components\hal\target\CC2650\rom; ..\..\..\..\..\Components\hal\target\CC2650TIRTOS; ..\..\..\..\..\Components\icall\include; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\nv; ..\..\..\..\..\Components\services\nv\cc26xx; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\icall; ..\..\..\..\..\Components\stack\icall\client; ..\..\..\..\..\Components\stack\zcl; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib; $DRIVERLIB$\..\..\packages\ti\boards\SensorTag\CC26XXST_0120; $DRIVERLIB$\..\..\packages\ti\boards\SensorTag\Devices; $DRIVERLIB$\..\..\packages\ti\boards\SensorTag\Interfaces
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorTag.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SensorTag.out
  ILINK.IlinkConfigDefines: CC2650=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.xcl
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; ..\..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../common/CC26xx/SensorTag/: board_key.c board_led.c
    ../../../common/CC26xx/: board_key.h board_led.h util.c util.h zcl_port.c zcl_port.h
    ./: sensortagapp.c sensortagapp.h znwk_config.h
  group Config
    ./: app.cfg cc26xx_app.icf
    ../../../Core/Thread/CC26xx/Config/: coreEndDevice.cfg coreEndDevice.xcl
  group Devices
    ../../../common/CC26xx/SensorTag/: bsp_i2c.c bsp_spi.c ext_flash.c sensor.c sensor_opt3001.c sensor_tmp007.c
    ./: sensor_bmp280.c sensor_hdc1000.c sensor_ppd42.c sensor_seeed_multi_gas.c
  group ICall
    ../../../../../Components/icall/ports/tirtos/: CryptoBoard.c ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../Components/icall/include/: CryptoBoard.h ICall.h ICallCC26xxDefs.h
    ../../../../../Components/applib/heap/: heapmgr.h
    ./: ICallAddrs.h
  group Sensor Controller
    scif/: scif.c scif.h scif_framework.c scif_osal_tirtos.c
  group Services
    ../../../../../Components/services/nv/: nvintf.h
    ../../../../../Components/services/nv/cc26xx/: nvoctp.c nvoctp.h
    ../../../../../Components/hal/target/_common/cc26xx/: pwrmon.c pwrmon.h
  group Startup
    ../../../common/CC26xx/SensorTag/: Board.c Board.h ccfg.c
    ./: main.c
  group ZCL
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_ms.c zcl_ms.h
  group ZStack
    ../../../../../Components/stack/icall/: zstack.h zstackmsg.h
    ../../../../../Components/stack/icall/client/: zstackapi.c zstackapi.h
